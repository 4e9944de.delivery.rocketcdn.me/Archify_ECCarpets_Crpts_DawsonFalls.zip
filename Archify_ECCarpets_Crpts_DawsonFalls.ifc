Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2025-10-14T09:29:49
Written by: ODA IFC SDK 22.8
Made in: 22.1.80.32 - Exporter 22.4.0.0 - Alternate UI 22.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status
COBie - Category: Project Information

# IfcSite, Default
RefLatitude: 51, 30, 0, 549316; RefLongitude: 0, -7, -34, -450321; RefElevation: 0 mm
COBie - Category: Project Information

# IfcBuilding
COBie - Category: Project Information

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
LongName: Level 0; Elevation: 0 mm
COBie - Category: Levels; Name: Level 0

# IfcCovering: Floor:Archify_ECCarpets_Carpets_DawsonFalls_Canyon5417, Floor:Archify_ECCarpets_Carpets_DawsonFalls_Canyon5417:221977
In: Level 0
Type - PredefinedType: FLOORING; Material: Archify_ECCarpets_Carpets_DawsonFalls_Canyon5417 12.5 mm
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: 0652:Carpets; CodePerformance: n/a; Color: n/a; Constituents: n/a; Description: Textured Tufted Loop Pile; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: n/a; Grade: n/a; Manufacturer: projects@eccarpets.com.au; Material: Wool; ModelNumber: Canyon 5417; ModelReference: Dawson Falls; Name: Carpets_DawsonFalls_Canyon5417_ECCarpets; NominalWidth: 3660 mm; ReplacementCost: n/a; Shape: Rectangle; Size: n/a; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: Archify; BIMObjectName: Archify_ECCarpets_Carpets_DawsonFalls_Canyon5417; ManufacturerName: EC Carpets; ManufacturerURL: eccarpets.com.au; NCSCode: 0652; NCSTitle: Carpets; NCSVersion: October2024; ProductInformation: https://www.eccarpets.com.au/product/pure-wool-carpets/dawson-falls/; Uniclass2015Code: Pr_35_57_11_64; Uniclass2015Title: Pile carpets; Uniclass2015Version: Products v1.35; Version: 1
Type - IFC - IfcExportAs: IfcCoveringType; IfcExportType: FLOORING
Classification: Pr_35_57_11_64 (Uniclass2015)
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59

# IfcCovering: Floor:Archify_ECCarpets_Carpets_DawsonFalls_Cascade5423, Floor:Archify_ECCarpets_Carpets_DawsonFalls_Cascade5423:222597
In: Level 0
Type - PredefinedType: FLOORING; Material: Archify_ECCarpets_Carpets_DawsonFalls_Cascade5423 12.5 mm
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: 0652:Carpets; CodePerformance: n/a; Color: n/a; Constituents: n/a; Description: Textured Tufted Loop Pile; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: n/a; Grade: n/a; Manufacturer: projects@eccarpets.com.au; Material: Wool; ModelNumber: Cascade 5423; ModelReference: Dawson Falls; Name: Carpets_DawsonFalls_Cascade5423_ECCarpets; NominalWidth: 3660 mm; ReplacementCost: n/a; Shape: Rectangle; Size: n/a; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: Archify; BIMObjectName: Archify_ECCarpets_Carpets_DawsonFalls_Cascade5423; ManufacturerName: EC Carpets; ManufacturerURL: eccarpets.com.au; NCSCode: 0652; NCSTitle: Carpets; NCSVersion: October2024; ProductInformation: https://www.eccarpets.com.au/product/pure-wool-carpets/dawson-falls/; Uniclass2015Code: Pr_35_57_11_64; Uniclass2015Title: Pile carpets; Uniclass2015Version: Products v1.35; Version: 1
Type - IFC - IfcExportAs: IfcCoveringType; IfcExportType: FLOORING
Classification: Pr_35_57_11_64 (Uniclass2015)
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59

# IfcCovering: Floor:Archify_ECCarpets_Carpets_DawsonFalls_Frosted5488, Floor:Archify_ECCarpets_Carpets_DawsonFalls_Frosted5488:222613
In: Level 0
Type - PredefinedType: FLOORING; Material: Archify_ECCarpets_Carpets_DawsonFalls_Frosted5488 12.5 mm
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: 0652:Carpets; CodePerformance: n/a; Color: n/a; Constituents: n/a; Description: Textured Tufted Loop Pile; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: n/a; Grade: n/a; Manufacturer: projects@eccarpets.com.au; Material: Wool; ModelNumber: Frosted 5488; ModelReference: Dawson Falls; Name: Carpets_DawsonFalls_Frosted5488_ECCarpets; NominalWidth: 3660 mm; ReplacementCost: n/a; Shape: Rectangle; Size: n/a; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: Archify; BIMObjectName: Archify_ECCarpets_Carpets_DawsonFalls_Frosted5488; ManufacturerName: EC Carpets; ManufacturerURL: eccarpets.com.au; NCSCode: 0652; NCSTitle: Carpets; NCSVersion: October2024; ProductInformation: https://www.eccarpets.com.au/product/pure-wool-carpets/dawson-falls/; Uniclass2015Code: Pr_35_57_11_64; Uniclass2015Title: Pile carpets; Uniclass2015Version: Products v1.35; Version: 1
Type - IFC - IfcExportAs: IfcCoveringType; IfcExportType: FLOORING
Classification: Pr_35_57_11_64 (Uniclass2015)
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59

# IfcCovering: Floor:Archify_ECCarpets_Carpets_DawsonFalls_Harmony5411, Floor:Archify_ECCarpets_Carpets_DawsonFalls_Harmony5411:222627
In: Level 0
Type - PredefinedType: FLOORING; Material: Archify_ECCarpets_Carpets_DawsonFalls_Harmony5411 12.5 mm
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: 0652:Carpets; CodePerformance: n/a; Color: n/a; Constituents: n/a; Description: Textured Tufted Loop Pile; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: n/a; Grade: n/a; Manufacturer: projects@eccarpets.com.au; Material: Wool; ModelNumber: Harmony 5411; ModelReference: Dawson Falls; Name: Carpets_DawsonFalls_Harmony5411_ECCarpets; NominalWidth: 3660 mm; ReplacementCost: n/a; Shape: Rectangle; Size: n/a; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: Archify; BIMObjectName: Archify_ECCarpets_Carpets_DawsonFalls_Harmony5411; ManufacturerName: EC Carpets; ManufacturerURL: eccarpets.com.au; NCSCode: 0652; NCSTitle: Carpets; NCSVersion: October2024; ProductInformation: https://www.eccarpets.com.au/product/pure-wool-carpets/dawson-falls/; Uniclass2015Code: Pr_35_57_11_64; Uniclass2015Title: Pile carpets; Uniclass2015Version: Products v1.35; Version: 1
Type - IFC - IfcExportAs: IfcCoveringType; IfcExportType: FLOORING
Classification: Pr_35_57_11_64 (Uniclass2015)
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59

# IfcCovering: Floor:Archify_ECCarpets_Carpets_DawsonFalls_Meadow5403, Floor:Archify_ECCarpets_Carpets_DawsonFalls_Meadow5403:222643
In: Level 0
Type - PredefinedType: FLOORING; Material: Archify_ECCarpets_Carpets_DawsonFalls_Meadow5403 12.5 mm
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: 0652:Carpets; CodePerformance: n/a; Color: n/a; Constituents: n/a; Description: Textured Tufted Loop Pile; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: n/a; Grade: n/a; Manufacturer: projects@eccarpets.com.au; Material: Wool; ModelNumber: Meadow 5403; ModelReference: Dawson Falls; Name: Carpets_DawsonFalls_Meadow5403_ECCarpets; NominalWidth: 3660 mm; ReplacementCost: n/a; Shape: Rectangle; Size: n/a; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: Archify; BIMObjectName: Archify_ECCarpets_Carpets_DawsonFalls_Meadow5403; ManufacturerName: EC Carpets; ManufacturerURL: eccarpets.com.au; NCSCode: 0652; NCSTitle: Carpets; NCSVersion: October2024; ProductInformation: https://www.eccarpets.com.au/product/pure-wool-carpets/dawson-falls/; Uniclass2015Code: Pr_35_57_11_64; Uniclass2015Title: Pile carpets; Uniclass2015Version: Products v1.35; Version: 1
Type - IFC - IfcExportAs: IfcCoveringType; IfcExportType: FLOORING
Classification: Pr_35_57_11_64 (Uniclass2015)
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59

# IfcCovering: Floor:Archify_ECCarpets_Carpets_DawsonFalls_Mist5428, Floor:Archify_ECCarpets_Carpets_DawsonFalls_Mist5428:222661
In: Level 0
Type - PredefinedType: FLOORING; Material: Archify_ECCarpets_Carpets_DawsonFalls_Mist5428 12.5 mm
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: 0652:Carpets; CodePerformance: n/a; Color: n/a; Constituents: n/a; Description: Textured Tufted Loop Pile; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: n/a; Grade: n/a; Manufacturer: projects@eccarpets.com.au; Material: Wool; ModelNumber: Mist 5428; ModelReference: Dawson Falls; Name: Carpets_DawsonFalls_Mist5428_ECCarpets; NominalWidth: 3660 mm; ReplacementCost: n/a; Shape: Rectangle; Size: n/a; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: Archify; BIMObjectName: Archify_ECCarpets_Carpets_DawsonFalls_Mist5428; ManufacturerName: EC Carpets; ManufacturerURL: eccarpets.com.au; NCSCode: 0652; NCSTitle: Carpets; NCSVersion: October2024; ProductInformation: https://www.eccarpets.com.au/product/pure-wool-carpets/dawson-falls/; Uniclass2015Code: Pr_35_57_11_64; Uniclass2015Title: Pile carpets; Uniclass2015Version: Products v1.35; Version: 1
Type - IFC - IfcExportAs: IfcCoveringType; IfcExportType: FLOORING
Classification: Pr_35_57_11_64 (Uniclass2015)
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59

# IfcCovering: Floor:Archify_ECCarpets_Carpets_DawsonFalls_Serenity5447, Floor:Archify_ECCarpets_Carpets_DawsonFalls_Serenity5447:222677
In: Level 0
Type - PredefinedType: FLOORING; Material: Archify_ECCarpets_Carpets_DawsonFalls_Serenity5447 12.5 mm
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: 0652:Carpets; CodePerformance: n/a; Color: n/a; Constituents: n/a; Description: Textured Tufted Loop Pile; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: n/a; Grade: n/a; Manufacturer: projects@eccarpets.com.au; Material: Wool; ModelNumber: Serenity 5447; ModelReference: Dawson Falls; Name: Carpets_DawsonFalls_Serenity5447_ECCarpets; NominalWidth: 3660 mm; ReplacementCost: n/a; Shape: Rectangle; Size: n/a; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: Archify; BIMObjectName: Archify_ECCarpets_Carpets_DawsonFalls_Serenity5447; ManufacturerName: EC Carpets; ManufacturerURL: eccarpets.com.au; NCSCode: 0652; NCSTitle: Carpets; NCSVersion: October2024; ProductInformation: https://www.eccarpets.com.au/product/pure-wool-carpets/dawson-falls/; Uniclass2015Code: Pr_35_57_11_64; Uniclass2015Title: Pile carpets; Uniclass2015Version: Products v1.35; Version: 1
Type - IFC - IfcExportAs: IfcCoveringType; IfcExportType: FLOORING
Classification: Pr_35_57_11_64 (Uniclass2015)
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59

# IfcCovering: Floor:Archify_ECCarpets_Carpets_DawsonFalls_Summit5445, Floor:Archify_ECCarpets_Carpets_DawsonFalls_Summit5445:222691
In: Level 0
Type - PredefinedType: FLOORING; Material: Archify_ECCarpets_Carpets_DawsonFalls_Summit5445 12.5 mm
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: 0652:Carpets; CodePerformance: n/a; Color: n/a; Constituents: n/a; Description: Textured Tufted Loop Pile; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: n/a; Grade: n/a; Manufacturer: projects@eccarpets.com.au; Material: Wool; ModelNumber: Summit 5445; ModelReference: Dawson Falls; Name: Carpets_DawsonFalls_Summit5445_ECCarpets; NominalWidth: 3660 mm; ReplacementCost: n/a; Shape: Rectangle; Size: n/a; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: Archify; BIMObjectName: Archify_ECCarpets_Carpets_DawsonFalls_Summit5445; ManufacturerName: EC Carpets; ManufacturerURL: eccarpets.com.au; NCSCode: 0652; NCSTitle: Carpets; NCSVersion: October2024; ProductInformation: https://www.eccarpets.com.au/product/pure-wool-carpets/dawson-falls/; Uniclass2015Code: Pr_35_57_11_64; Uniclass2015Title: Pile carpets; Uniclass2015Version: Products v1.35; Version: 1
Type - IFC - IfcExportAs: IfcCoveringType; IfcExportType: FLOORING
Classification: Pr_35_57_11_64 (Uniclass2015)
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59

# IfcCovering: Floor:Archify_ECCarpets_Carpets_DawsonFalls_Sunlit5454, Floor:Archify_ECCarpets_Carpets_DawsonFalls_Sunlit5454:222707
In: Level 0
Type - PredefinedType: FLOORING; Material: Archify_ECCarpets_Carpets_DawsonFalls_Sunlit5454 12.5 mm
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: 0652:Carpets; CodePerformance: n/a; Color: n/a; Constituents: n/a; Description: Textured Tufted Loop Pile; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: n/a; Grade: n/a; Manufacturer: projects@eccarpets.com.au; Material: Wool; ModelNumber: Sunlit 5454; ModelReference: Dawson Falls; Name: Carpets_DawsonFalls_Sunlit5454_ECCarpets; NominalWidth: 3660 mm; ReplacementCost: n/a; Shape: Rectangle; Size: n/a; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: Archify; BIMObjectName: Archify_ECCarpets_Carpets_DawsonFalls_Sunlit5454; ManufacturerName: EC Carpets; ManufacturerURL: eccarpets.com.au; NCSCode: 0652; NCSTitle: Carpets; NCSVersion: October2024; ProductInformation: https://www.eccarpets.com.au/product/pure-wool-carpets/dawson-falls/; Uniclass2015Code: Pr_35_57_11_64; Uniclass2015Title: Pile carpets; Uniclass2015Version: Products v1.35; Version: 1
Type - IFC - IfcExportAs: IfcCoveringType; IfcExportType: FLOORING
Classification: Pr_35_57_11_64 (Uniclass2015)
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
